# Repository LBassett21/Keyboard-PCB-Design

## KiCad design Simple PCB.kicad_pcb

Schematic: Simple PCB.sch

Parts:
C1, C2: 22pF; C_0805_2012Metric
C3: 1uF; C_0805_2012Metric
C4, C5, C6, C7: 0.1uF; C_0805_2012Metric
D1, D2, D3, D4: SOD-123; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
MX1, MX2, MX3, MX4: MX-1U
R1, R4: 10k; R_0805_2012Metric
R2, R3: 22; R_0805_2012Metric
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
USB1: Molex-0548190589
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C4.1, C5.1, C6.1, C7.1, F1.1, R1.2, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
COL0: MX1.1, MX3.1
COL1: MX2.1, MX4.1
D+: R2.2, USB1.3
D-: R3.2, USB1.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R4.1, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), USB1.1, Y1.2, Y1.4
unnamed: C1.1, U1.17 (XTAL1), Y1.1
unnamed: C2.1, U1.16 (XTAL2), Y1.3
unnamed: C3.1, U1.6 (UCAP)
unnamed: D1.2, MX1.2
unnamed: D2.2, MX2.2
unnamed: D3.2, MX3.2
unnamed: D4.2, MX4.2
unnamed: R1.1, SW1.2, U1.13 (~RESET)
unnamed: R2.1, U1.4 (D+)
unnamed: R3.1, U1.3 (D-)
unnamed: R4.2, U1.33 (~HWB~/PE2)
ROW0: D1.1, D2.1
ROW1: D3.1, D4.1
VCC: F1.2, USB1.5

Board: 2 copper layers, 24 parts (0 on the bottom side), 20 nets, no tracks yet.

## Commit log

2019-02-26 Added submodules
2019-02-26 Added footprint libraries
2019-02-26 Added MCU
2019-02-26 Added ground
2019-02-26 Added capasitors and resistors
2019-02-26 Finished MCU
2019-02-26 Added USB Connector and rows and collums
2019-02-26 Assigned most footprints
    Need to fix 32u4 mcu
